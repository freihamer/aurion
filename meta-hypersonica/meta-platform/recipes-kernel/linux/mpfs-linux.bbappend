FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append := " file://leds_triggers.cfg "